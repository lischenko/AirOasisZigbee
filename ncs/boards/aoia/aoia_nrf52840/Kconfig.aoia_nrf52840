## ncs/boards/aoia/aoia_nrf52840/board.yml
```yaml
board:
  name: aoia_nrf52840
  full_name: AirOasis Teyleten nice!nano-compatible nRF52840
  vendor: others
  socs:
    - name: nrf52840
```
